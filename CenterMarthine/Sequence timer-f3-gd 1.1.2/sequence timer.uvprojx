# Keil uVision project sequence timer.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sequence timer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\LCD;.\GUI;.\HARDWARE\TOUCH;.\FLAG&DATA;.\HARDWARE\RS485;.\HARDWARE\RS232;.\HARDWARE\IIC;.\HARDWARE\24CXX;.\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./GUI/: activity.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./: README.c
  group HARDWARE
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/TOUCH/: ctiic.c
    ./HARDWARE/RS485/: rs485.c
    ./HARDWARE/RS232/: rs232.c
    ./HARDWARE/KEY/: key.c
  group GUI
    ./GUI/: gui.c
  group FLAG&DATA
    ./FLAG&DATA/: data.c
